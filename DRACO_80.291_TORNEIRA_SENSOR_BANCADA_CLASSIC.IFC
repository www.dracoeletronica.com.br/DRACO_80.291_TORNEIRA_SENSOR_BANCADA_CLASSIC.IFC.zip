Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_80.291_TORNEIRA_SENSOR_BANCADA_CLASSIC.IFC
Time: 2022-07-07T20:17:48
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: DRACO_80.291_TORNEIRA_SENSOR_BANCADA_CLASSIC
In: Default Storey
Material: Brass
